# Keil uVision project cmd_app.uvprojx, settings and files
target cmd_app (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cmd_app +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;..\..\Drivers/CMSIS/Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\system;..\user;..\firmware\uart;..\..\..\cmd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group document
    ../document/: updateLog.txt
  group drivers
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
    ../../drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c
  group system
    ../system/: cqueue.c
  group user
    ../../drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../user/: main.c stm32f1xx_it.c
  group cmd
    ../../../cmd/: cmd_reboot.c cmd_test.c cmd_version.c commandConsole.c FreeRTOS_CLI.c userCommand.c
  group firmware/uart
    ../firmware/uart/: uart.c usart.c
software components: CMSIS:CORE 4.3.0
